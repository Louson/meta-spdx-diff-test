inherit sbom-diff

SPDX_REF_FILE = "file://${TOPDIR}/../sbom-data/reference-sbom.spdx.json;name=spdxref"
SRC_URI[spdxref.sha256sum] = "87be74f9449e09929cd1f2e1e03e34ef1c8c68f6ba46cba3621dc1b8e05d5e30"
