inherit sbom-diff

SPDX_REF_FILE = "https://raw.githubusercontent.com/bootlin/sbom-diff/refs/heads/main/tests/reference-sbom.spdx.json"
SRC_URI[sha256sum] = "0be012006c33fc63b8c23aff1f87abb8deed1b9ef7b12f4148d8f8ab55293849"
